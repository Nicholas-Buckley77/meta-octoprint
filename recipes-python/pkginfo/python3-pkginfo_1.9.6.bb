SUMMARY = "Pattern matching and various utilities for file systems paths."

HOMEPAGE = "https://pypi.python.org/pypi/pkginfo/"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=8227180126797a0148f94f483f3e1489"

SRC_URI[sha256sum] = "8fd5896e8718a4372f0ea9cc9d96f6417c9b986e23a4d116dda26b62cc29d046"

inherit pypi setuptools3
