SUMMARY = "Emoji for Python"
HOMEPAGE = "https://pypi.org/project/emoji/"

PYPI_PACKAGE = "emoji"
LICENSE = "CLOSED"
#LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=9d99980d85e5f81e38ee21f7f4f730d4"
SRC_URI[sha256sum] = "5f4a15b7caa9c67fc11be9d90a822e3fa26aeb4e5b7bd2ded754b394d9c47869"

inherit pypi setuptools3

