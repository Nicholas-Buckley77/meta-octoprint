SUMMARY = "A least recently used (LRU) cache implementation"

HOMEPAGE = "https://pypi.python.org/pypi/pylru/"

LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=b234ee4d69f5fce4486a80fdaf4a4263"

SRC_URI[md5sum] = "101486c319fa219f147b8811975780d9"
SRC_URI[sha256sum] = "47ad140a63ab9389648dadfbb4330700e0ffeeb28ec04664ee47d37ed133b0f4"

inherit pypi setuptools3
