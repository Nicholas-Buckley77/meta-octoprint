SUMMARY = "A collection of cache libraries in the same API interface. Extracted from werkzeug."

HOMEPAGE = "https://pypi.org/project/cachelib/"

LICENSE = "CLOSED"
#LIC_FILES_CHKSUM = "file://LICENSE;md5=a32a7594742a04098377c0c777ec1af7"
SRC_URI[sha256sum] = "593faeee62a7c037d50fc835617a01b887503f972fb52b188ae7e50e9cb69740"

inherit pypi setuptools3
