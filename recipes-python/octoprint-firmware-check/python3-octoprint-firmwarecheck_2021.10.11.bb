SUMMARY = "The Firmware Check plugin tries to identify printers."
HOMEPAGE = "https://pypi.org/project/OctoPrint-FirmwareCheck/"

PYPI_PACKAGE = "OctoPrint-FirmwareCheck"

LICENSE = "AGPL-3.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=73f1eb20517c55bf9493b7dd6e480788"
SRC_URI[sha256sum] = "506861624a8faf2633765eaf2aa6635bead8afc7471a375f399cbe5f33d0f99e"

inherit pypi setuptools3
