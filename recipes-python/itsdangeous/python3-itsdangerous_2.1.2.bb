SUMMARY = "Various helpers to pass trusted data to untrusted environments"
HOMEPAGE = "http://packages.python.org/itsdangerous/"

LICENSE = "CLOSED"
#LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=370799bf709a1e4a6a369fa089ac73a6"
SRC_URI[sha256sum] = "5dbbc68b317e5e42f327f9021763545dc3fc3bfe22e6deb96aaf1fc38874156a"

inherit pypi setuptools3
