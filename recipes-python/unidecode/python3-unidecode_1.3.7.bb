SUMMARY = "ASCII transliterations of Unicode text"

HOMEPAGE = "https://pypi.python.org/pypi/Unidecode"

PYPI_PACKAGE = "Unidecode"

LICENSE = "GPLv2+"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b234ee4d69f5fce4486a80fdaf4a4263"
SRC_URI[sha256sum] = "3c90b4662aa0de0cb591884b934ead8d2225f1800d8da675a7750cbc3bd94610"

inherit pypi setuptools3
